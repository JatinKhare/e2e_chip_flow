* LVS Extracted Netlist from Layout
* Generated by Calibre xRC

.SUBCKT adder32 VDD VSS a[0] a[1] ... b[31] carry_in sum[0] ... carry_out overflow
* Transistor-level netlist extracted from GDS
* Includes all transistors, resistors, capacitors from layout

* Input register flip-flop instances
X_a_reg_0 ... VDD VSS DFFQX1
X_a_reg_1 ... VDD VSS DFFQX1
* ... (all cells extracted from layout)

* Parasitic resistors
R1 n1 n2 2.4
* ... (all wire resistances)

* Parasitic capacitors
C1 n1 VSS 0.25fF
C2 n1 n3 0.08fF ;* coupling cap
* ... (all wire capacitances)

.ENDS adder32

* This netlist is compared against schematic netlist for LVS
